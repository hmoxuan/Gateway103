# IAR project stm32demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\CMSIS\CMSIS_inc; ..\CMSIS\CMSIS_src; ..\FWlib\FWlib_inc; ..\FWlib\FWlib_src; ..\CMSIS\CMSIS_inc; ..\CMSIS\CMSIS_src; ..\FWlib\FWlib_inc; ..\FWlib\FWlib_src; ..\User\HardwareDrv\HardwareDrv_inc; ..\User\main_routine; ..\User\App\AppConfig; ..\User\App\AppDebug; ..\User\App\AppTools; ..\User\App\AppSoftWare
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32demo.hex
  ILINK.IlinkOutputFile: stm32demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS/CMSIS_inc
    ../CMSIS/CMSIS_inc/: core_cm3.h core_cmFunc.h core_cmInstr.h stm32f10x.h system_stm32f10x.h
  group CMSIS/CMSIS_satrtup
    ../CMSIS/CMSIS_startup/: startup_stm32f10x_hd.s
  group CMSIS/CMSIS_src
    ../CMSIS/CMSIS_src/: core_cm3.c system_stm32f10x.c
  group FWlib/FWLib_inc
    ../FWlib/FWlib_inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group FWlib/FWlib_src
    ../FWlib/FWlib_src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User/App/AppConfig
    ../User/App/AppConfig/: myportmacro.h NetCmdDefine.h NetInterface.h ZigBeeCmdDefine.h ZigBeeInterface.h
  group User/App/AppDebug
    ../User/App/AppDebug/: AppDebugCfg.h AppDebugFunc.c AppDebugFunc.h
  group User/App/AppSoftWare
    ../User/App/AppSoftWare/: AppSoftWareDriver.c AppSoftWareDriver.h AppSoftWareHandler.c AppSoftWareHandler.h
  group User/App/AppTools
    ../User/App/AppTools/: mystring.c mystring.h
  group User/HardwareDrv/HardwareDrv_inc
    ../User/HardwareDrv/HardwareDrv_inc/: beep.h delay.h exti.h keys.h leds.h stm32timer.h sys.h usart.h wdg.h
  group User/HardwareDrv/HardwareDrv_src
    ../User/HardwareDrv/HardwareDrv_src/: beep.c delay.c exti.c keys.c leds.c stm32timer.c sys.c usart.c wdg.c
  group User/main_routine
    ../User/main_routine/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h

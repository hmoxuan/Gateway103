<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>CMSIS</name>
    <group>
      <name>CMSIS_inc</name>
      <file>
        <name>$PROJ_DIR$\..\CMSIS\CMSIS_inc\core_cm3.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\CMSIS\CMSIS_inc\core_cmFunc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\CMSIS\CMSIS_inc\core_cmInstr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\CMSIS\CMSIS_inc\stm32f10x.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\CMSIS\CMSIS_inc\system_stm32f10x.h</name>
      </file>
    </group>
    <group>
      <name>CMSIS_satrtup</name>
      <file>
        <name>$PROJ_DIR$\..\CMSIS\CMSIS_startup\startup_stm32f10x_hd.s</name>
      </file>
    </group>
    <group>
      <name>CMSIS_src</name>
      <file>
        <name>$PROJ_DIR$\..\CMSIS\CMSIS_src\core_cm3.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\CMSIS\CMSIS_src\system_stm32f10x.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>FWlib</name>
    <group>
      <name>FWLib_inc</name>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_inc\misc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_inc\stm32f10x_adc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_inc\stm32f10x_bkp.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_inc\stm32f10x_can.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_inc\stm32f10x_cec.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_inc\stm32f10x_crc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_inc\stm32f10x_dac.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_inc\stm32f10x_dbgmcu.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_inc\stm32f10x_dma.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_inc\stm32f10x_exti.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_inc\stm32f10x_flash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_inc\stm32f10x_fsmc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_inc\stm32f10x_gpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_inc\stm32f10x_i2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_inc\stm32f10x_iwdg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_inc\stm32f10x_pwr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_inc\stm32f10x_rcc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_inc\stm32f10x_rtc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_inc\stm32f10x_sdio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_inc\stm32f10x_spi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_inc\stm32f10x_tim.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_inc\stm32f10x_usart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_inc\stm32f10x_wwdg.h</name>
      </file>
    </group>
    <group>
      <name>FWlib_src</name>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_src\misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_src\stm32f10x_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_src\stm32f10x_bkp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_src\stm32f10x_can.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_src\stm32f10x_cec.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_src\stm32f10x_crc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_src\stm32f10x_dac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_src\stm32f10x_dbgmcu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_src\stm32f10x_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_src\stm32f10x_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_src\stm32f10x_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_src\stm32f10x_fsmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_src\stm32f10x_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_src\stm32f10x_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_src\stm32f10x_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_src\stm32f10x_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_src\stm32f10x_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_src\stm32f10x_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_src\stm32f10x_sdio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_src\stm32f10x_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_src\stm32f10x_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_src\stm32f10x_usart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\FWlib\FWlib_src\stm32f10x_wwdg.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>User</name>
    <group>
      <name>App</name>
      <group>
        <name>AppConfig</name>
        <file>
          <name>$PROJ_DIR$\..\User\App\AppConfig\myportmacro.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\App\AppConfig\NetCmdDefine.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\App\AppConfig\NetInterface.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\App\AppConfig\ZigBeeCmdDefine.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\App\AppConfig\ZigBeeInterface.h</name>
        </file>
      </group>
      <group>
        <name>AppDebug</name>
        <file>
          <name>$PROJ_DIR$\..\User\App\AppDebug\AppDebugCfg.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\App\AppDebug\AppDebugFunc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\App\AppDebug\AppDebugFunc.h</name>
        </file>
      </group>
      <group>
        <name>AppSoftWare</name>
        <file>
          <name>$PROJ_DIR$\..\User\App\AppSoftWare\AppSoftWareDriver.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\App\AppSoftWare\AppSoftWareDriver.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\App\AppSoftWare\AppSoftWareHandler.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\App\AppSoftWare\AppSoftWareHandler.h</name>
        </file>
      </group>
      <group>
        <name>AppTools</name>
        <file>
          <name>$PROJ_DIR$\..\User\App\AppTools\mystring.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\App\AppTools\mystring.h</name>
        </file>
      </group>
    </group>
    <group>
      <name>HardwareDrv</name>
      <group>
        <name>HardwareDrv_inc</name>
        <file>
          <name>$PROJ_DIR$\..\User\HardwareDrv\HardwareDrv_inc\beep.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\HardwareDrv\HardwareDrv_inc\delay.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\HardwareDrv\HardwareDrv_inc\exti.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\HardwareDrv\HardwareDrv_inc\keys.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\HardwareDrv\HardwareDrv_inc\leds.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\HardwareDrv\HardwareDrv_inc\stm32timer.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\HardwareDrv\HardwareDrv_inc\sys.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\HardwareDrv\HardwareDrv_inc\usart.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\HardwareDrv\HardwareDrv_inc\wdg.h</name>
        </file>
      </group>
      <group>
        <name>HardwareDrv_src</name>
        <file>
          <name>$PROJ_DIR$\..\User\HardwareDrv\HardwareDrv_src\beep.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\HardwareDrv\HardwareDrv_src\delay.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\HardwareDrv\HardwareDrv_src\exti.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\HardwareDrv\HardwareDrv_src\keys.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\HardwareDrv\HardwareDrv_src\leds.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\HardwareDrv\HardwareDrv_src\stm32timer.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\HardwareDrv\HardwareDrv_src\sys.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\HardwareDrv\HardwareDrv_src\usart.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\User\HardwareDrv\HardwareDrv_src\wdg.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>main_routine</name>
      <file>
        <name>$PROJ_DIR$\..\User\main_routine\main.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\main_routine\stm32f10x_conf.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\main_routine\stm32f10x_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\main_routine\stm32f10x_it.h</name>
      </file>
    </group>
  </group>
</project>


